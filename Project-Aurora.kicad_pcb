# Repository Project-Aurora/Project-Aurora

## KiCad design Project-Aurora.kicad_pcb

Parts:
C1, C3, C4, C9, C10, C11, C12, C13, C14, C17, C18, C26, C27, C28, C29, C30: 0.1uF; C_0805
C2, C5, C6, C7, C8, C16, C22, C23, C24, C25: 1uF; C_0805
C15, C19, C21: 2.2uF; C_0805
C20: 100uF; C_1206
D132: LED; LED_0805
P1: USB_OTG; Micro-USB_629105150521
P2: FLASH_HDR; JLINK_NEEDLE
P3, P4, P5, P6, P7, P8, P9, P10, P11, P12: DBG; PINTST
P13: CONN_01X04; Pin_Header_Straight_1x04_Pitch2.00mm
R1, R9: 20k; R_0805
R2, R4: 100k; R_0805
R5, R6: 33; R_0805
R7: 5M; R_0805
R8, R10, R14: 1k; R_0805
R12, R13: 100; R_0805
SW1: Reset; KSEM31GLFS
U1: MK20DX256VLH7; LQFP-64_10x10mm_Pitch0.5mm
U2, U3: IS31FL3732; UQFN-40-1EP_5x5mm_Pitch0.4mm
U6: Case-Ground; PKRHC
W1: TEST; Test_Point_2Pads
X1: CRYSTAL_SMD; crystal_FA238-TSX3225

Connections:
+3V3: C1.1, C2.1, C3.1, C13.1, C14.1, C15.1, C16.1, C17.1, C19.2, P2.1 (VCCS), P3.1, R4.1, R8.2, R10.2, U1.3 (VDD), U1.7 (VOUT33), U1.21 (VBAT), U1.30 (VDD), U1.48 (VDD), U2.27 (VIO), U3.27 (VIO)
+5V: C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C20.2, C21.2, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, P1.1 (VCC), P2.5 (VKS), P7.1, P13.1, U1.8 (VREGIN), U2.1 (PVCC), U2.4 (VCC), U2.20 (PVCC), U2.26 (AVCC), U3.1 (PVCC), U3.4 (VCC), U3.20 (PVCC), U3.23 (ADDR2), U3.26 (AVCC)
/C_Filt: C4.1, U2.29 (C_FILT)
/C_Filt-2: C18.1, U3.29 (C_FILT)
/D+: R5.2, U1.5 (USB0_DP)
/D+5V: P1.3 (D+), P13.3, R5.1
/D-: R6.2, U1.6 (USB0_DM)
/D-5V: P1.2 (D-), P13.2, R6.1
/INTB: R4.2, U1.38 (PTB3), U3.5 (INTB)
/Keymatrix/Col1: U1.49 (PTC4/LLWU_P8); also elsewhere on the board
/Keymatrix/Col2: U1.50 (PTC5/LLWU_P9); also elsewhere on the board
/Keymatrix/Col3: U1.51 (PTC6/LLWU_P10); also elsewhere on the board
/Keymatrix/Col4: U1.61 (PTD4/LLWU_P14); also elsewhere on the board
/Keymatrix/Col5: U1.62 (PTD5); also elsewhere on the board
/Keymatrix/Col6: U1.63 (PTD6/LLWU_P15); also elsewhere on the board
/Keymatrix/Col7: U1.64 (PTD7); also elsewhere on the board
/Keymatrix/Col8: U1.59 (PTD2/LLWU_P13); also elsewhere on the board
/Keymatrix/Col9: U1.58 (PTD1); also elsewhere on the board
/Keymatrix/Col10: U1.57 (PTD0/LLWU_P12); also elsewhere on the board
/Keymatrix/Col11: U1.26 (PTA4/LLWU_P3); also elsewhere on the board
/Keymatrix/Col12: U1.28 (PTA12); also elsewhere on the board
/Keymatrix/Col13: U1.29 (PTA13/LLWU_P4); also elsewhere on the board
/Keymatrix/Col14: U1.46 (PTC3/LLWU_P7); also elsewhere on the board
/Keymatrix/Row1: U1.56 (PTC11/LLWU_P11); also elsewhere on the board
/Keymatrix/Row2: U1.55 (PTC10); also elsewhere on the board
/Keymatrix/Row3: U1.54 (PTC9); also elsewhere on the board
/Keymatrix/Row4: U1.53 (PTC8); also elsewhere on the board
/Keymatrix/Row5: U1.52 (PTC7); also elsewhere on the board
/LED1A/CA1: U2.32 (CA1); also elsewhere on the board
/LED1A/CA2: U2.33 (CA2); also elsewhere on the board
/LED1A/CA3: U2.34 (CA3); also elsewhere on the board
/LED1A/CA4: U2.35 (CA4); also elsewhere on the board
/LED1A/CA5: U2.36 (CA5); also elsewhere on the board
/LED1A/CA6: U2.37 (CA6); also elsewhere on the board
/LED1A/CA7: U2.38 (CA7); also elsewhere on the board
/LED1A/CA8: U2.39 (CA8); also elsewhere on the board
/LED1A/CA9: U2.40 (CA9); also elsewhere on the board
/LED1B/CB1: U2.11 (CB1); also elsewhere on the board
/LED1B/CB2: U2.12 (CB2); also elsewhere on the board
/LED1B/CB3: U2.13 (CB3); also elsewhere on the board
/LED1B/CB4: U2.14 (CB4); also elsewhere on the board
/LED1B/CB5: U2.15 (CB5); also elsewhere on the board
/LED1B/CB6: U2.16 (CB6); also elsewhere on the board
/LED1B/CB7: U2.17 (CB7); also elsewhere on the board
/LED1B/CB8: U2.18 (CB8); also elsewhere on the board
/LED1B/CB9: U2.19 (CB9); also elsewhere on the board
/LED2A/CA1: U3.32 (CA1); also elsewhere on the board
/LED2A/CA2: U3.33 (CA2); also elsewhere on the board
/LED2A/CA3: U3.34 (CA3); also elsewhere on the board
/LED2A/CA4: U3.35 (CA4); also elsewhere on the board
/LED2A/CA5: U3.36 (CA5); also elsewhere on the board
/LED2A/CA6: U3.37 (CA6); also elsewhere on the board
/LED2A/CA7: U3.38 (CA7); also elsewhere on the board
/LED2A/CA8: U3.39 (CA8); also elsewhere on the board
/LED2A/CA9: U3.40 (CA9); also elsewhere on the board
/LED2B/CB1: U3.11 (CB1); also elsewhere on the board
/LED2B/CB2: U3.12 (CB2); also elsewhere on the board
/LED2B/CB3: U3.13 (CB3); also elsewhere on the board
/LED2B/CB4: U3.14 (CB4); also elsewhere on the board
/LED2B/CB5: U3.15 (CB5); also elsewhere on the board
/LED2B/CB6: U3.16 (CB6); also elsewhere on the board
/LED2B/CB7: U3.17 (CB7); also elsewhere on the board
/LED2B/CB8: U3.18 (CB8); also elsewhere on the board
/LED2B/CB9: U3.19 (CB9); also elsewhere on the board
/MCU_RESET: C30.1, P2.10 (RES), P8.1, SW1.1, U1.34 (RESET_b)
/PTA5: D132.2 (A), P2.9 (TRST), P9.1, U1.27 (PTA5)
/RX0: P2.8 (TDI), P10.1, U1.23 (PTA1)
/R_Ext: R1.2, U2.28 (R_EXT)
/R_Ext-2: R9.2, U3.28 (R_EXT)
/SCL: R8.1, U1.35 (PTB0/LLWU_P5), U2.22 (SCL), U3.22 (SCL), W1.2
/SDA: R10.1, U1.36 (PTB1), U2.21 (SDA), U3.21 (SDA), W1.1
/SDB: R2.2, U1.37 (PTB2), U2.25 (SDB), U3.25 (SDB)
/SWD_CLK: P2.4 (TCK), P6.1, R12.1
/SWD_DIO: P2.2 (TMS), P4.1, R13.1
/Sync: U2.30 (SYNC), U3.30 (SYNC)
/TX0: P2.6 (TDO), P12.1, U1.24 (PTA2/TRACE_SWD)
/TX1: P2.7 (RTCK), P11.1, U1.60 (PTD3)
/X+: U1.32 (EXTAL0/PTA18), X1.1
/X-: U1.33 (XDAL0/PTA19), X1.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C20.1, C21.1, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, P1.5 (GND), P2.3 (GND), P5.1, P13.4, R1.1, R2.1, R7.2, R9.1, R14.1, SW1.2, U1.4 (VSS), U1.31 (VSS), U1.47 (VSS), U2.7 (GND), U2.8 (GND), U2.9 (GND), U2.23 (ADDR2), U2.24 (ADDR1), U2.31 (GND), U2.41 (Pad), U3.7 (GND), U3.8 (GND), U3.9 (GND), U3.24 (ADDR1), U3.31 (GND), U3.41 (Pad), X1.3 (case)
GNDCase: P1.6 (shield), U6.1
unnamed: C19.1, R7.1
unnamed: D132.1 (K), R14.2
unnamed: R12.2, U1.22 (PTA0/SWD_CLK)
unnamed: R13.2, U1.25 (PTA3/SWD_DIO)

Parts:
D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D131: Led_RGB_CA; RGB

Connections:
/LED2B/CB1: D17.1, D25.2 (R), D26.2 (R), D27.2 (R), D28.2 (R), D29.2 (R), D30.2 (R), D31.2 (R), D32.2 (R), D131.2 (R); also elsewhere on the board
/LED2B/CB2: D18.1, D25.1, D26.3 (G), D27.3 (G), D28.3 (G), D29.3 (G), D30.3 (G), D31.3 (G), D32.3 (G), D131.3 (G); also elsewhere on the board
/LED2B/CB3: D19.1, D25.3 (G), D26.1, D27.4 (B), D28.4 (B), D29.4 (B), D30.4 (B), D31.4 (B), D32.4 (B), D131.4 (B); also elsewhere on the board
/LED2B/CB4: D20.1, D25.4 (B), D26.4 (B), D27.1; also elsewhere on the board
/LED2B/CB5: D21.1, D28.1; also elsewhere on the board
/LED2B/CB6: D22.1, D23.4 (B), D24.4 (B), D29.1, D131.1; also elsewhere on the board
/LED2B/CB7: D17.4 (B), D18.4 (B), D19.4 (B), D20.4 (B), D21.4 (B), D22.4 (B), D23.1, D24.3 (G), D30.1; also elsewhere on the board
/LED2B/CB8: D17.3 (G), D18.3 (G), D19.3 (G), D20.3 (G), D21.3 (G), D22.3 (G), D23.3 (G), D24.1, D31.1; also elsewhere on the board
/LED2B/CB9: D17.2 (R), D18.2 (R), D19.2 (R), D20.2 (R), D21.2 (R), D22.2 (R), D23.2 (R), D24.2 (R), D32.1; also elsewhere on the board

Parts:
D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64: Led_RGB_CA; RGB

Connections:
/LED2A/CA1: D49.1, D57.2 (R), D58.2 (R), D59.2 (R), D60.2 (R), D61.2 (R), D62.2 (R), D63.2 (R), D64.2 (R); also elsewhere on the board
/LED2A/CA2: D50.1, D57.1, D58.3 (G), D59.3 (G), D60.3 (G), D61.3 (G), D62.3 (G), D63.3 (G), D64.3 (G); also elsewhere on the board
/LED2A/CA3: D51.1, D57.3 (G), D58.1, D59.4 (B), D60.4 (B), D61.4 (B), D62.4 (B), D63.4 (B), D64.4 (B); also elsewhere on the board
/LED2A/CA4: D52.1, D57.4 (B), D58.4 (B), D59.1; also elsewhere on the board
/LED2A/CA5: D53.1, D60.1; also elsewhere on the board
/LED2A/CA6: D54.1, D55.4 (B), D56.4 (B), D61.1; also elsewhere on the board
/LED2A/CA7: D49.4 (B), D50.4 (B), D51.4 (B), D52.4 (B), D53.4 (B), D54.4 (B), D55.1, D56.3 (G), D62.1; also elsewhere on the board
/LED2A/CA8: D49.3 (G), D50.3 (G), D51.3 (G), D52.3 (G), D53.3 (G), D54.3 (G), D55.3 (G), D56.1, D63.1; also elsewhere on the board
/LED2A/CA9: D49.2 (R), D50.2 (R), D51.2 (R), D52.2 (R), D53.2 (R), D54.2 (R), D55.2 (R), D56.2 (R), D64.1; also elsewhere on the board

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D129, D130: Led_RGB_CA; RGB

Connections:
/LED1B/CB1: D1.1, D9.2 (R), D10.2 (R), D11.2 (R), D12.2 (R), D13.2 (R), D14.2 (R), D15.2 (R), D16.2 (R), D129.1, D130.2 (R); also elsewhere on the board
/LED1B/CB2: D2.1, D9.1, D10.3 (G), D11.3 (G), D12.3 (G), D13.3 (G), D14.3 (G), D15.3 (G), D16.3 (G), D130.3 (G); also elsewhere on the board
/LED1B/CB3: D3.1, D9.3 (G), D10.1, D11.4 (B), D12.4 (B), D13.4 (B), D14.4 (B), D15.4 (B), D16.4 (B), D130.4 (B); also elsewhere on the board
/LED1B/CB4: D4.1, D9.4 (B), D10.4 (B), D11.1; also elsewhere on the board
/LED1B/CB5: D5.1, D12.1; also elsewhere on the board
/LED1B/CB6: D6.1, D7.4 (B), D8.4 (B), D13.1; also elsewhere on the board
/LED1B/CB7: D1.4 (B), D2.4 (B), D3.4 (B), D4.4 (B), D5.4 (B), D6.4 (B), D7.1, D8.3 (G), D14.1, D129.4 (B); also elsewhere on the board
/LED1B/CB8: D1.3 (G), D2.3 (G), D3.3 (G), D4.3 (G), D5.3 (G), D6.3 (G), D7.3 (G), D8.1, D15.1, D129.3 (G), D130.1; also elsewhere on the board
/LED1B/CB9: D1.2 (R), D2.2 (R), D3.2 (R), D4.2 (R), D5.2 (R), D6.2 (R), D7.2 (R), D8.2 (R), D16.1, D129.2 (R); also elsewhere on the board

Parts:
D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48: Led_RGB_CA; RGB

Connections:
/LED1A/CA1: D33.1, D41.2 (R), D42.2 (R), D43.2 (R), D44.2 (R), D45.2 (R), D46.2 (R), D47.2 (R), D48.2 (R); also elsewhere on the board
/LED1A/CA2: D34.1, D41.1, D42.3 (G), D43.3 (G), D44.3 (G), D45.3 (G), D46.3 (G), D47.3 (G), D48.3 (G); also elsewhere on the board
/LED1A/CA3: D35.1, D41.3 (G), D42.1, D43.4 (B), D44.4 (B), D45.4 (B), D46.4 (B), D47.4 (B), D48.4 (B); also elsewhere on the board
/LED1A/CA4: D36.1, D41.4 (B), D42.4 (B), D43.1; also elsewhere on the board
/LED1A/CA5: D37.1, D44.1; also elsewhere on the board
/LED1A/CA6: D38.1, D39.4 (B), D40.4 (B), D45.1; also elsewhere on the board
/LED1A/CA7: D33.4 (B), D34.4 (B), D35.4 (B), D36.4 (B), D37.4 (B), D38.4 (B), D39.1, D40.3 (G), D46.1; also elsewhere on the board
/LED1A/CA8: D33.3 (G), D34.3 (G), D35.3 (G), D36.3 (G), D37.3 (G), D38.3 (G), D39.3 (G), D40.1, D47.1; also elsewhere on the board
/LED1A/CA9: D33.2 (R), D34.2 (R), D35.2 (R), D36.2 (R), D37.2 (R), D38.2 (R), D39.2 (R), D40.2 (R), D48.1; also elsewhere on the board

Parts:
D65, D66, D67, D68, D69, D70, D71, D72, D73, D74, D75, D76, D77, D78, D79, D80, D81, D82, D83, D84, D85, D86, D87, D88, D89, D90, D91, D92, D93, D94, D95, D96, D97, D98, D99, D100, D101, D102, D103, D104, D105, D106, D107, D108, D109, D110, D111, D112, D113, D114, D115, D116, D117, D118, D119, D120, D121, D122, D123, D124, D126, D127, D128: D; SOD-123
SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW31, SW32, SW33, SW34, SW35, SW36, SW37, SW38, SW39, SW40, SW41, SW42, SW43, SW44, SW45, SW46, SW47, SW48, SW49, SW50, SW51, SW52, SW53, SW54, SW55, SW56, SW57, SW58, SW59, SW60, SW61, SW62, SW63, SW64, SW65, SW66: SW_PUSH; MX1A

Connections:
/Keymatrix/Col1: SW2.1, SW3.1, SW4.1, SW5.1, SW6.1, SW66.1; also elsewhere on the board
/Keymatrix/Col2: SW7.1, SW8.1, SW9.1, SW10.1, SW11.1; also elsewhere on the board
/Keymatrix/Col3: SW12.1, SW13.1, SW14.1, SW15.1, SW16.1; also elsewhere on the board
/Keymatrix/Col4: SW17.1, SW18.1, SW19.1, SW21.1; also elsewhere on the board
/Keymatrix/Col5: SW20.1, SW22.1, SW23.1, SW24.1; also elsewhere on the board
/Keymatrix/Col6: SW25.1, SW26.1, SW27.1, SW29.1; also elsewhere on the board
/Keymatrix/Col7: SW28.1, SW30.1, SW31.1, SW32.1, SW33.1; also elsewhere on the board
/Keymatrix/Col8: SW34.1, SW35.1, SW36.1, SW37.1; also elsewhere on the board
/Keymatrix/Col9: SW38.1, SW39.1, SW40.1, SW41.1; also elsewhere on the board
/Keymatrix/Col10: SW42.1, SW43.1, SW44.1, SW45.1; also elsewhere on the board
/Keymatrix/Col11: SW46.1, SW47.1, SW48.1, SW49.1, SW50.1; also elsewhere on the board
/Keymatrix/Col12: SW51.1, SW52.1, SW53.1, SW54.1, SW55.1; also elsewhere on the board
/Keymatrix/Col13: SW56.1, SW57.1, SW58.1, SW59.1, SW60.1; also elsewhere on the board
/Keymatrix/Col14: SW61.1, SW62.1, SW63.1, SW64.1, SW65.1; also elsewhere on the board
/Keymatrix/Row1: D69.1 (K), D74.1 (K), D79.1 (K), D84.1 (K), D87.1 (K), D92.1 (K), D96.1 (K), D100.1 (K), D104.1 (K), D108.1 (K), D113.1 (K), D118.1 (K), D123.1 (K), D128.1 (K); also elsewhere on the board
/Keymatrix/Row1Col1: D69.2 (A), SW6.2
/Keymatrix/Row1Col2: D74.2 (A), SW11.2
/Keymatrix/Row1Col3: D79.2 (A), SW16.2
/Keymatrix/Row1Col4: D84.2 (A), SW21.2
/Keymatrix/Row1Col5: D87.2 (A), SW24.2
/Keymatrix/Row1Col6: D92.2 (A), SW29.2
/Keymatrix/Row1Col7: D96.2 (A), SW33.2
/Keymatrix/Row1Col8: D100.2 (A), SW37.2
/Keymatrix/Row1Col9: D104.2 (A), SW41.2
/Keymatrix/Row1Col10: D108.2 (A), SW45.2
/Keymatrix/Row1Col11: D113.2 (A), SW50.2
/Keymatrix/Row1Col12: D118.2 (A), SW55.2
/Keymatrix/Row1Col13: D123.2 (A), SW60.2
/Keymatrix/Row1Col14: D128.2 (A), SW65.2
/Keymatrix/Row2: D65.1 (K), D70.1 (K), D75.1 (K), D80.1 (K), D83.1 (K), D88.1 (K), D91.1 (K), D97.1 (K), D101.1 (K), D105.1 (K), D109.1 (K), D114.1 (K), D119.1 (K), D124.1 (K); also elsewhere on the board
/Keymatrix/Row2Col1: D65.2 (A), SW2.2
/Keymatrix/Row2Col2: D70.2 (A), SW7.2
/Keymatrix/Row2Col3: D75.2 (A), SW12.2
/Keymatrix/Row2Col4: D80.2 (A), SW17.2
/Keymatrix/Row2Col5: D83.2 (A), SW20.2
/Keymatrix/Row2Col6: D88.2 (A), SW25.2
/Keymatrix/Row2Col7: D91.2 (A), SW28.2
/Keymatrix/Row2Col8: D97.2 (A), SW34.2
/Keymatrix/Row2Col9: D101.2 (A), SW38.2
/Keymatrix/Row2Col10: D105.2 (A), SW42.2
/Keymatrix/Row2Col11: D109.2 (A), SW46.2
/Keymatrix/Row2Col12: D114.2 (A), SW51.2
/Keymatrix/Row2Col13: D119.2 (A), SW56.2
/Keymatrix/Row2Col14: D124.2 (A), SW61.2, SW62.2
/Keymatrix/Row3: D66.1 (K), D71.1 (K), D76.1 (K), D81.1 (K), D85.1 (K), D89.1 (K), D93.1 (K), D98.1 (K), D102.1 (K), D106.1 (K), D110.1 (K), D115.1 (K), D120.1 (K); also elsewhere on the board
/Keymatrix/Row3Col1: D66.2 (A), SW3.2
/Keymatrix/Row3Col2: D71.2 (A), SW8.2
/Keymatrix/Row3Col3: D76.2 (A), SW13.2
/Keymatrix/Row3Col4: D81.2 (A), SW18.2
/Keymatrix/Row3Col5: D85.2 (A), SW22.2
/Keymatrix/Row3Col6: D89.2 (A), SW26.2
/Keymatrix/Row3Col7: D93.2 (A), SW30.2
/Keymatrix/Row3Col8: D98.2 (A), SW35.2
/Keymatrix/Row3Col9: D102.2 (A), SW39.2
/Keymatrix/Row3Col10: D106.2 (A), SW43.2
/Keymatrix/Row3Col11: D110.2 (A), SW47.2
/Keymatrix/Row3Col12: D115.2 (A), SW52.2
/Keymatrix/Row3Col13: D120.2 (A), SW57.2
/Keymatrix/Row4: D67.1 (K), D72.1 (K), D77.1 (K), D82.1 (K), D86.1 (K), D90.1 (K), D94.1 (K), D99.1 (K), D103.1 (K), D107.1 (K), D111.1 (K), D116.1 (K), D121.1 (K), D126.1 (K); also elsewhere on the board
/Keymatrix/Row4Col1: D67.2 (A), SW4.2, SW66.2
/Keymatrix/Row4Col2: D72.2 (A), SW9.2
/Keymatrix/Row4Col3: D77.2 (A), SW14.2
/Keymatrix/Row4Col4: D82.2 (A), SW19.2
/Keymatrix/Row4Col5: D86.2 (A), SW23.2
/Keymatrix/Row4Col6: D90.2 (A), SW27.2
/Keymatrix/Row4Col7: D94.2 (A), SW31.2
/Keymatrix/Row4Col8: D99.2 (A), SW36.2
/Keymatrix/Row4Col9: D103.2 (A), SW40.2
/Keymatrix/Row4Col10: D107.2 (A), SW44.2
/Keymatrix/Row4Col11: D111.2 (A), SW48.2
/Keymatrix/Row4Col12: D116.2 (A), SW53.2
/Keymatrix/Row4Col13: D121.2 (A), SW58.2
/Keymatrix/Row4Col14: D126.2 (A), SW63.2
/Keymatrix/Row5: D68.1 (K), D73.1 (K), D78.1 (K), D95.1 (K), D112.1 (K), D117.1 (K), D122.1 (K), D127.1 (K); also elsewhere on the board
/Keymatrix/Row5Col1: D68.2 (A), SW5.2
/Keymatrix/Row5Col2: D73.2 (A), SW10.2
/Keymatrix/Row5Col3: D78.2 (A), SW15.2
/Keymatrix/Row5Col7: D95.2 (A), SW32.2
/Keymatrix/Row5Col11: D112.2 (A), SW49.2
/Keymatrix/Row5Col12: D117.2 (A), SW54.2
/Keymatrix/Row5Col13: D122.2 (A), SW59.2
/Keymatrix/Row5Col14: D127.2 (A), SW64.2

Board: 4 copper layers, 285.0 x 94.6 mm, 275 parts (59 on the bottom side), 148 nets.

Other parts of the board:
FID1, FID3, FID5, FID7: Nothing-to-see-here; Fiducial_1mm_Dia_2.54mm_Outer_CopperTop
FID2, FID4, FID6, FID8, FID9, FID10, FID11, FID12: Nothing-to-see-here; Fiducial_1mm_Dia_2.54mm_Outer_CopperBottom
empty2, empty5, empty6: PKRH
empty3, empty4: PKRHSL

## Commit log

2016-04-03 Added files via upload
2016-04-03 Adding Librarys
2016-04-03 Adding Footprint Librarys
2016-04-03 Optimised Routing of Ground Trace
2016-04-04 Prevented potential Ground loop
    On the Shielding of the USB Connecor
2016-04-04 Clean up LED-Schematics
    Luckily I didn't make any mistakes in the first run.
    (Unless I made the same Mistake twice)
2016-04-04 Added Fiducials, i2c Testpoints and a Filter-Cap
    Fiducials: 4 Two-Sided feducials in the Corners, 4 Feducials on the Back near the ICs (these might be Overkill)
    i2c Testpoints: Makes debugging less of a hassle, also tuned track-lengths of SCL and SDA
    Filter-Cap: Supposed to prevent high-pitched buzzing during load
2016-04-05 Cleaned up Schematic and Libraries
2016-04-05 Forgot some Stuff in the last Commit
2016-04-05 Picked more appropriate i2c Debug Port
2016-04-07 Switched from using a Dedicated one to the MCUs integrated Voltage Regulator for 3.3V. The LED-Drivers are now using 5V.
2016-04-08 Cleaned up some Routing Stuff.
2016-04-08 Properly named Case Ground.
2016-04-08 Removed References to unused Librarys.
2016-04-11 Did some visual cleanup.
2016-04-12 Added Debug-Port
    In order to avoid buying the JLink Needle.
2016-06-10 Switched to a different USB Port and 100uF Cap
    also added a USB-Debug Header and did some cleanup
2016-06-11 Add proper Reference to Footprint Libraries
